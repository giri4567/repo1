# Keil uVision project 4396.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Atmel Atmel Wireless & uC
  output: 4396
  c flags: Optimize=8 SizeSpeed=1
